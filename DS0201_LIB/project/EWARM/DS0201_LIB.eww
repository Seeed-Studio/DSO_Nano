<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\DS0201_LIB.ewp</path>
  </project>
  <batchBuild/>
</workspace>


