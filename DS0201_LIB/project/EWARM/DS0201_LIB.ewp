# IAR project DS0201_LIB.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: VECT_TAB_FLASH
  ICCARM.CCIncludePath2: ..\..\..\USBLib\inc; ..\..\..\library\inc; ..\..\..\USBLib\inc; ..\..\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DS0201_LIB.hex
  ILINK.IlinkOutputFile: DS0201_LIB.out
  ILINK.IlinkIcfFile: C:\DSO\DSO BenF v3\DS0201_LIB\project\EWARM\LIB_cortex.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../source/: HW_V1_Config.c Lcd.c main.c memory.c msd.c scsi_data.c stm32f10x_it.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group EWARM
    ./: cortexm3_macro.s stm32f10x_vector.c
  group STlib
    ../../../library/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c
  group USBlib
    ../../../USBLib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
